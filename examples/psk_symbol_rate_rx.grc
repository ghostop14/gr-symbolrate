options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: psk_symbol_rate_rx
    output_language: python
  states: {}

blocks:
- name: bpsk_constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 315e6
  states: {}
- name: demod_filter_cutoff
  id: variable
  parameters:
    comment: |-
      Seems to work well if this is
      reasonably around the symbol/baud rate

      symbols_per_sec/2*1.1
    value: 2000*1.1
  states: {}
- name: filter_cutoff
  id: variable
  parameters:
    value: 60e3/2*1.34
  states: {}
- name: filter_transition
  id: variable
  parameters:
    value: filter_cutoff*0.1
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab_control@0:0,0,1,2
    type: real
    value: 315e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: threshold
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab_control@0:0,4,1,2
    label: Threshold
    type: real
    value: '-30'
  states: {}
- name: working_samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'False'
    ramp: '1'
    threshold: threshold
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/psk_data_w_clockMM.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /tmp/psk31_test_string_2M.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '20'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: bpsk_constellation
    fmax: '1000'
    fmin: '0'
    loop_bw: 2*math.pi/100
    showports: 'True'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: int(samp_rate/working_samp_rate)
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, filter_cutoff, filter_transition)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    comment: Need math.pi
    imports: import math
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '6543'
    send_eof: 'True'
    type: byte
    vlen: '64'
  states: {state: disabled}
- name: note_0_1
  id: note
  parameters:
    note: Tab 1 GUI
  states: {}
- name: note_1_1
  id: note
  parameters:
    note: XLating FIR Settings
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tab_control@1:0,3,2,3
    size: '1024'
    type: complex
    xmax: '20'
    xmin: '-20'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: working_samp_rate
    fc: freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab_control@0:1,0,2,3
    showports: 'True'
    type: complex
    ymin: '-100'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: tab_control@2:0,4,2,1
    label1: Avg
    max: '50'
    min: '0'
    name: Long-term average
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab_control@0:4,0,2,6
    label1: ''
    label2: ''
    size: '16000'
    srate: working_samp_rate
    tr_chan: '1'
    tr_delay: '0.001'
    tr_level: '0.3'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: tab_control@2:0,0,2,4
    label1: Inst Rate
    label2: Short Avg
    label3: Long Avg
    nconnections: '3'
    size: '32000'
    srate: working_samp_rate
    tr_delay: '0.1'
    tr_level: '10'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '100'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: tab_control@1:0,0,2,3
    label1: Symbols
    name: '"Symbol Output"'
    size: '32000'
    srate: working_samp_rate
    tr_delay: '0.5e-3'
    tr_level: '0.01'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: working_samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: tab_control@0:1,3,2,3
    int_max: '-10'
    int_min: '-80'
    showports: 'True'
    type: complex
  states: {}
- name: symbolrate_symbolrate_0
  id: symbolrate_symbolrate
  parameters:
    log_rates: 'False'
    samp_rate: working_samp_rate
    valid_max: '45'
    valid_min: '20.0'
  states: {}
- name: tab_control
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,6,6
    label0: Raw Signal
    label1: Symbols and Demod
    label2: Symbol Rate
    num_tabs: '3'
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', digital_constellation_receiver_cb_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_const_sink_x_1, '0']
- [blocks_stream_to_vector_0, '0', network_udp_sink_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_uchar_to_float_0, '0', symbolrate_symbolrate_0, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_file_sink_0, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_stream_to_vector_0, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_uchar_to_float_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [symbolrate_symbolrate_0, '0', qtgui_time_sink_x_1, '0']
- [symbolrate_symbolrate_0, '1', qtgui_time_sink_x_1, '1']
- [symbolrate_symbolrate_0, '2', qtgui_number_sink_0, '0']
- [symbolrate_symbolrate_0, '2', qtgui_time_sink_x_1, '2']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-70-gf44384ae
