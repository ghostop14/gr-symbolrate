options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: doorbell_ook_from_file
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 315e6
  states: {}
- name: demod_filter_cutoff
  id: variable
  parameters:
    comment: |-
      Seems to work well if this is
      reasonably around the symbol/baud rate

      symbols_per_sec/2*1.1
    value: 3000*1.1
  states: {}
- name: first_filter_cutoff
  id: variable
  parameters:
    value: '6000'
  states: {}
- name: first_filter_transition
  id: variable
  parameters:
    value: first_filter_cutoff*0.2
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab_control@0:0,0,1,2
    type: real
    value: 315e6
  states: {}
- name: offset_tune
  id: variable
  parameters:
    comment: If you +tuned, use - val here
    value: '-500e3'
  states: {}
- name: samp_per_symbol
  id: variable
  parameters:
    comment: |-
      need to decimate any raw samples/symbol
      rates down to working_samp_rate
      if counted in other tools like Audacity
      from raw IQ data.
    value: working_samp_rate/symbols_per_sec
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: symbols_per_sec
  id: variable
  parameters:
    value: '2874'
  states: {}
- name: threshold
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab_control@0:0,4,1,2
    label: Threshold
    type: real
    value: '-30'
  states: {}
- name: trigger_offset
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: working_samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'False'
    ramp: '1'
    threshold: threshold
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_1
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'False'
    ramp: '0'
    threshold: '-10'
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1.0*trigger_offset'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1.0*trigger_offset'
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/ook_data_w_clockMM.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /tmp/inputfile-315.5MHz-2.4M.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_symbol*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset_tune
    decim: int(samp_rate/working_samp_rate)
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, first_filter_cutoff, first_filter_transition)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    comment: Need math.pi
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: demod_filter_cutoff*1.1
    decim: '1'
    gain: '1'
    samp_rate: working_samp_rate
    type: fir_filter_fff
    width: demod_filter_cutoff*0.1
    win: window.WIN_BLACKMAN
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '6543'
    send_eof: 'True'
    type: byte
    vlen: '64'
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    comment: This is already demodulated
    note: Tab 2 GUI
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Tab 2 GUI
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: Tab 1 GUI
  states: {}
- name: note_1_1
  id: note
  parameters:
    note: XLating FIR Settings
  states: {}
- name: note_2
  id: note
  parameters:
    note: Because clock out is only 1 symbol/clock, can't tie this to a GUI w a diff sample rate or you have 2 inputs w diff rates.
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: working_samp_rate
    fc: freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab_control@0:1,0,2,3
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: tab_control@2:0,4,2,1
    label1: Avg
    max: '4000'
    min: '0'
    name: Long-term average
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab_control@0:4,0,2,6
    label1: ''
    label2: ''
    size: '32768'
    srate: working_samp_rate
    tr_chan: '1'
    tr_delay: '0.001'
    tr_level: '0.3'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab_control@1:1,0,2,3
    label1: ''
    label2: ''
    name: Raw Signal
    size: '32768'
    srate: working_samp_rate
    tr_chan: '1'
    tr_delay: '0.001'
    tr_level: '0.3'
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: tab_control@2:0,0,1,3
    label1: Inst Rate
    label2: Short Avg
    label3: Long Avg
    nconnections: '3'
    size: '16000'
    srate: working_samp_rate
    tr_delay: '0.5e-3'
    tr_level: '2500'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '5000'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: tab_control@1:6,0,2,6
    label1: Clock Out
    label2: Symbols Out
    name: '"Symbol Output"'
    nconnections: '2'
    size: '12000'
    srate: working_samp_rate
    tr_delay: '0.5e-3'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: tab_control@1:1,3,2,3
    label1: ''
    name: '"Demodulator Output"'
    size: '1024'
    srate: working_samp_rate
    tr_delay: '0.001'
    tr_level: '1.0'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: working_samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: tab_control@0:1,3,2,3
    int_max: '-10'
    int_min: '-80'
    showports: 'True'
    type: complex
  states: {}
- name: symbolrate_symbolrate_0
  id: symbolrate_symbolrate
  parameters:
    log_rates: 'True'
    samp_rate: working_samp_rate
    valid_max: '3600.0'
    valid_min: '2100.0'
  states: {}
- name: tab_control
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,6,6
    label0: Raw Signal
    label1: Symbols and Demod
    label2: Symbol Rate
    num_tabs: '3'
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', blocks_complex_to_mag_0, '0']
- [analog_pwr_squelch_xx_1, '0', qtgui_time_sink_x_3, '0']
- [blocks_add_const_vxx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_add_const_vxx_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [blocks_complex_to_mag_0, '0', analog_pwr_squelch_xx_1, '0']
- [blocks_complex_to_mag_0, '0', low_pass_filter_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_stream_to_vector_0, '0', network_udp_sink_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_2, '1']
- [blocks_uchar_to_float_0, '0', symbolrate_symbolrate_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_file_sink_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_null_sink_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_stream_to_vector_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_add_const_vxx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_add_const_vxx_0, '0']
- [low_pass_filter_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_2, '0']
- [symbolrate_symbolrate_0, '0', qtgui_time_sink_x_1, '0']
- [symbolrate_symbolrate_0, '1', qtgui_time_sink_x_1, '1']
- [symbolrate_symbolrate_0, '2', qtgui_number_sink_0, '0']
- [symbolrate_symbolrate_0, '2', qtgui_time_sink_x_1, '2']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-70-gf44384ae
