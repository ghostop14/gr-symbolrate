options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: fsk_symbol_rate_rx
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 315e6
  states: {}
- name: demod_filter_cutoff
  id: variable
  parameters:
    comment: |-
      Seems to work well if this is
      reasonably around the symbol/baud rate

      symbols_per_sec/2*1.1
    value: 2000*1.1
  states: {}
- name: demod_gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab_control@1:0,0,1,2
    label: Demod Gain Multiplier
    type: real
    value: '2'
  states: {}
- name: filter_cutoff
  id: variable
  parameters:
    value: fsk_deviation_hz/2*1.34
  states: {}
- name: filter_transition
  id: variable
  parameters:
    value: filter_cutoff*0.1
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab_control@0:0,0,1,2
    type: real
    value: 315e6
  states: {}
- name: fsk_deviation_hz
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab_control@0:0,2,1,2
    type: real
    value: 60e3
  states: {}
- name: original_samp_per_symbol
  id: variable
  parameters:
    comment: |-
      Open raw IQ in audacity and measure
      peak to trough.  Take sample # from there.
    value: '40'
  states: {state: disabled}
- name: samp_per_symbol
  id: variable
  parameters:
    comment: |-
      need to decimate any raw samples/symbol
      rates down to working_samp_rate
      if counted in other tools like Audacity
      from raw IQ data.
    value: working_samp_rate/symbols_per_sec
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: symbol_offset
  id: variable_qtgui_entry
  parameters:
    comment: '0.7'
    gui_hint: tab_control@1:0,2,1,2
    label: Symbol Detection Signal Shift
    type: real
    value: '0'
  states: {}
- name: symbols_per_sec
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab_control@1:0,4,1,2
    label: Symbols/Sec (baud rate)
    type: real
    value: '3947.4'
  states: {}
- name: symbols_per_sec
  id: variable
  parameters:
    value: working_samp_rate/samp_per_symbol
  states: {state: disabled}
- name: threshold
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab_control@0:0,4,1,2
    label: Threshold
    type: real
    value: '-30'
  states: {}
- name: working_samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'False'
    ramp: '1'
    threshold: threshold
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.01'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.01'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/fsk_data_w_clockMM.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /tmp/inputfile_2.4M.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '20'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_symbol*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: int(samp_rate/working_samp_rate)
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, filter_cutoff, filter_transition)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    comment: Need math.pi
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: symbols_per_sec*1.1
    decim: '1'
    gain: demod_gain
    samp_rate: working_samp_rate
    type: fir_filter_fff
    width: symbols_per_sec*0.1
    win: window.WIN_HAMMING
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '6543'
    send_eof: 'True'
    type: byte
    vlen: '64'
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    comment: This is already demodulated
    note: Tab 2 GUI
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Tab 2 GUI
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: Tab 1 GUI
  states: {}
- name: note_1
  id: note
  parameters:
    note: Use these if measured
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: Use these if experimenting
  states: {}
- name: note_1_1
  id: note
  parameters:
    note: XLating FIR Settings
  states: {}
- name: note_2
  id: note
  parameters:
    note: Because clock out is only 1 symbol/clock, can't tie this to a GUI w a diff sample rate or you have 2 inputs w diff rates.
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab_control@0:1,3,2,3
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: working_samp_rate
    fc: freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab_control@0:1,0,2,3
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: working_samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab_control@1:4,0,2,6
    name: Symbol Rate Analyzer
    showports: 'True'
    type: float
    wintype: window.WIN_BLACKMAN
    ymax: '-0'
    ymin: '-180'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: tab_control@2:0,4,2,1
    label1: Avg
    max: '4500'
    min: '0'
    name: Long-term average
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab_control@0:4,0,2,6
    label1: ''
    label2: ''
    size: '32768'
    srate: working_samp_rate
    tr_chan: '1'
    tr_delay: '0.001'
    tr_level: '0.3'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab_control@1:1,0,2,3
    label1: ''
    label2: ''
    name: Raw Signal
    size: '32768'
    srate: working_samp_rate
    tr_chan: '1'
    tr_delay: '0.001'
    tr_level: '0.3'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: tab_control@2:0,0,2,4
    label1: Inst Rate
    label2: Short Avg
    label3: Long Avg
    nconnections: '3'
    size: '32000'
    srate: working_samp_rate
    tr_delay: '0.1'
    tr_level: '3500'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '10000'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: tab_control@1:6,0,2,6
    label1: Clock Out
    label2: Symbols Out
    name: '"Symbol Output"'
    nconnections: '2'
    size: '8096'
    srate: working_samp_rate
    tr_delay: '0.5e-3'
    tr_level: symbol_offset
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: tab_control@1:1,3,2,3
    label1: ''
    name: '"Demodulator Output"'
    size: '1024'
    srate: working_samp_rate
    tr_delay: '0.001'
    tr_level: '1.0'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '20'
    ymin: '-20'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: working_samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: tab_control@0:1,3,2,3
    int_max: '-10'
    int_min: '-80'
    showports: 'True'
    type: complex
  states: {}
- name: symbolrate_symbolrate_0
  id: symbolrate_symbolrate
  parameters:
    log_rates: 'False'
    samp_rate: working_samp_rate
    valid_max: '4500.0'
    valid_min: '3000.0'
  states: {}
- name: tab_control
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,6,6
    label0: Raw Signal
    label1: Symbols and Demod
    label2: Symbol Rate
    num_tabs: '3'
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_3, '0']
- [blocks_add_const_vxx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_add_const_vxx_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_stream_to_vector_0, '0', network_udp_sink_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_2, '1']
- [blocks_uchar_to_float_0, '0', symbolrate_symbolrate_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_file_sink_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_null_sink_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_stream_to_vector_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_add_const_vxx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_add_const_vxx_0, '0']
- [low_pass_filter_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_2, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_2, '0']
- [symbolrate_symbolrate_0, '0', qtgui_time_sink_x_1, '0']
- [symbolrate_symbolrate_0, '1', qtgui_time_sink_x_1, '1']
- [symbolrate_symbolrate_0, '2', qtgui_number_sink_0, '0']
- [symbolrate_symbolrate_0, '2', qtgui_time_sink_x_1, '2']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-70-gf44384ae
